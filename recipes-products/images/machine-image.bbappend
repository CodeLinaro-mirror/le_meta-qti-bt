# BT OPEN SOURCE PACKAGES
include qcm6490/qcm6490-bt-image.inc